# Keil uVision project IIC_Demo.uvprojx, settings and files
target ble-sdk (5060960::V5.06 update 7 (build 960)::.\AC506u7)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: BT_NFC
  AfterMake: fromelf --bin --output=s.bin !L
  AfterMake: Xincboot_tool s.bin download.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c include: .\App;.\Library_function\M0\Ble\btstack;.\Library_function\M0\Ble\btstack\src;.\Library_function\M0\Ble\btstack\src\ble;.\Library_function\M0\Ble\btstack\src\ble\gatt-service;.\Library_function\M0\Ble\btstack\src\classic;.\Library_function\M0\Ble\OTA_ble;.\Library_function\M0\Bsp;.\Library_function\M0\Delay;.\Library_function\M0\LIB;.\Library_function\M0\Startup;.\Library_function\Bluetooth;.\Library_function\Peripheral\NFC;.\Library_function\Peripheral\Buzzer;.\Library_function\Peripheral\LED;.\Library_function\Peripheral\Buzzer
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Library_function\M0\Startup\cpu.scat
  group startup
    ./Library_function/M0/Startup/: core_cm0.c startup_xinc.s system_xinc.c
  group App
    ./App/: main.c
    ./Library_function/M0/LIB/: Xinc_ble_sdk_nonlowpowerv1.2.lib
  group NFC
    ./Library_function/Peripheral/NFC/: ISO14443.c RFID_6.c
  group Ble
    ./Library_function/M0/Ble/: patch.c
    ./App/: gatt_client.c
    ./Library_function/M0/Bsp/: rf_driver.c
    ./Library_function/Bluetooth/: xinchip_ota.c
  group bsp
    ./Library_function/M0/Bsp/: bsp_gpio.c bsp_uart.c bsp_wdog.c bsp_retarget.c bsp_spi_master.c bsp_systick.c
  group BT
    ./Library_function/Bluetooth/: BT.c
  group LED
    ./Library_function/Peripheral/LED/: LED.c
  group Delay
    ./Library_function/M0/Delay/: M0_Delay.c
  group Buzzer
    ./Library_function/Peripheral/Buzzer/: Buzzer.c
